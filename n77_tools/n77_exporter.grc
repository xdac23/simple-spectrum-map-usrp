options:
  parameters:
    generate_options: qt_gui
    id: n77_exporter
    output_language: python
    title: N77 Data Exporter
  states: {}

blocks:
- name: duration
  id: variable
  parameters:
    value: '1'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '5'
    stop: '100'
    value: '40'
    widget: counter
  states: {}
- name: iteration
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '45'
    value: '1'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    start: 3300e6
    step: 'samp_rate '
    stop: 4200e6
    value: 3300e6+ (samp_rate * iteration)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/dan/Workspace/Gnuradio_scripts/Measurements/C2/c2-n77-12.dat
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/dan/Workspace/Gnuradio_scripts/test_data
    type: complex
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 20000000*duration
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    plotconst: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: tuning
    dc_offs_enb0: auto
    gain0: gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_file_sink_1, '0']
- [blocks_throttle_0, '0', blocks_head_0, '0']
- [qtgui_sink_x_0, freq, qtgui_sink_x_0, freq]
- [qtgui_sink_x_0, freq, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
