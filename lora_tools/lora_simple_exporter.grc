options:
  parameters:
    generate_options: qt_gui
    id: lora_data_exporter
    output_language: python
    title: LoRa Data Exporter
  states: {}

blocks:
- name: duration
  id: variable
  parameters:
    value: '3'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/dan/Workspace/Gnuradio_scripts/Measurements/C4/c4-lora-short.dat
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 10000000*duration
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: freq
    gain0: rf_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
