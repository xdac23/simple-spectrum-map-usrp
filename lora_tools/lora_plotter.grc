options:
  parameters:
    generate_options: qt_gui
    id: lora_simple_plot
    output_language: python
    title: Simple Plotter for LoRa
  states: {}

blocks:
- name: duration
  id: variable
  parameters:
    value: '3'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/dan/Workspace/Gnuradio_scripts/Measurements/lablora-long.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', fosphor_glfw_sink_c_0, '0']

metadata:
  file_format: 1
